# Keil uVision project btn.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: btn
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c Thread.c Button.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, Device:STM32Cube Framework:Classic 1.1.1, Device:STM32Cube HAL:Common 1.1.1, Device:STM32Cube HAL:Cortex 1.1.1, Device:STM32Cube HAL:DMA 1.1.1, Device:STM32Cube HAL:GPIO 1.1.1, Device:STM32Cube HAL:RCC 1.1.1, Device:STM32Cube HAL:SRAM 1.1.1, Device:Startup 2.1.1, RTOS:uC/OS Common 1.0.0, RTOS:uC/OS Kernel 1.0.0
